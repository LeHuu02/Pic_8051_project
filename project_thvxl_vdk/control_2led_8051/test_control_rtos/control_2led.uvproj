# Keil uVision project control_2led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: control_2led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: control_2led.c control_2led_test1.txt control2led.txt FreeRTOS_8051.txt
