# Keil uVision project BAI2_LMD02_8051_8X8_QUET_COT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BAI2_LMD02_8051_8X8_QUET_COT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BAI2_LMD02_8051_8X8_QUET_COT.c
