# Keil uVision project BAI1_LMD01_TEST_8051_8X8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BAI1_LMD01_TEST_8051_8X8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BAI1_LMD01_TEST_8051_8X8.c
